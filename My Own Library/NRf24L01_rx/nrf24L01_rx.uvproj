# Keil uVision project nrf24L01_rx.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: nrf24L01_rx +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: nrf24L01_main_rx.c nrf_lib.h
